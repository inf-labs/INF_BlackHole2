# Keil uVision project INF_BlackHole2.uvprojx, settings and files
target INF_BlackHole2 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: INF_BlackHole2 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Applications;.\Drivers;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport\ST\STM32F10x;.\Libraries\CMSIS\DeviceSupport\ST;.\USB\STM32_USB-FS-Device_Driver\inc;.\USB\USB_User_Driver
  asm define: SYSCLK_FREQ_72MHz
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./applications/: main.c ahrs.c control.c stm32f10x_it.c
    ./Applications/: task.c function.c
    ./Libraries/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SCI
    ./applications/: telecontrol.c
    ./Applications/: data_interaction.c param.c ilink.c
  group BSP
    ./Drivers/: delay.c led.c systick.c mpu6500.c mpu6500_spi.c ms5611.c ms5611_spi.c pwm_in.c pwm_out.c usart3.c wifi_module.c ultrasonic_usart.c eeprom.c battery_check.c
    ./Applications/: ultrasonic.c
  group LIB
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./Libraries/CMSIS/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group USB_User_Driver
    ./USB/USB_User_Driver/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group STM32_USB-FS-Device_Driver
    ./USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Doc
    ./Documents/: readme.txt updata_log.txt code_specification.txt
